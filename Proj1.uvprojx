# Keil uVision project Proj1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Proj1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Include;.\Source\ModBus;.\Source\MyPeriph
  memory RVCT4: ROM 0x8000000 size 0xf7ff
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./Source/: main.c mysettings.c ssec.c system_f051.c startup_stm32f0xx.s
  group MyPeriph
    ./Source/MyPeriph/: mydac.c mydma.c MyEXTI.c myflash.c mygpio.c myiwdg.c mytimer.c myuart.c fpuart1_051.c myadc051.c
  group ModBus
    ./Source/ModBus/: ModBus.c
    ./Source/: ModBusParams.c
